# IAR project LCD.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: aplicacao.c aplicacao.h defines.h events.c events.h main.c serial.c serial.h stm8_tsl_api.c stm8_tsl_api.h stm8_tsl_checkconfig.h stm8_tsl_conf.h stm8_tsl_conf_RC_TOADAPT.h stm8_tsl_internal.h stm8_tsl_multichannelkey.c stm8_tsl_multichannelkey.h stm8_tsl_rc_acquisition.c stm8_tsl_rc_acquisition.h stm8_tsl_services.c stm8_tsl_services.h stm8_tsl_singlechannelkey.c stm8_tsl_singlechannelkey.h stm8_tsl_timebase.c stm8_tsl_timebase.h stm8s_adc1.c stm8s_adc1.h stm8s_clk.c stm8s_clk.h stm8s_flash.c stm8s_flash.h stm8s_gpio.c stm8s_gpio.h stm8s_it.c stm8s_it.h stm8s_tim1.c stm8s_tim1.h stm8s_tim2.c stm8s_tim2.h stm8s_tim4.c stm8s_tim4.h
